FILESEXTRAPATHS:prepend:minnow := "${THISDIR}/bluez5:"
SRC_URI += "file://0001-Sleep-during-bt-to-avoid-timeout.patch"
SRC_URI += "file://0002-Print-GATT-dbg-msgs.patch"
